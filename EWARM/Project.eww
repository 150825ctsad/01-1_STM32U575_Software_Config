<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\01-1_STM32U575_Software_Config.ewp</path>
  </project>
  <batchBuild />
</workspace>
